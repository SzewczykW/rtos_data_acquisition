# Keil uVision project data_acquisition.uvprojx, settings and files
target data_acquistion (6240000::V6.24::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: data_acquisition
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: include;include\app;include\utils;include\drivers;include\net
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group app
    ./src/app/: command_parser.c data_acquisition.c main.c system.c
    ./include/app/: command_parser.h data_acquisition.h main.h system.h config.h
  group drivers
    ./src/drivers/: adc.c ne555.c
    ./include/drivers/: adc.h ne555.h
  group net
    ./src/net/: protocol.c udp_socket.c
    ./include/net/: protocol.h udp_socket.h
  group tasks
    ./src/tasks/: task_acquisition.c task_acquisition.h task_network.c task_network.h
  group utils
    ./include/utils/: panic.h logger.h
    ./src/utils/: logger.c panic.c
software components: CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS Driver:GPIO:Custom 1.0.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Message Buffer 11.2.0, RTOS:Timers 11.2.0, CMSIS Driver:Ethernet MAC 2.14.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:USART 2.13.0, Device:GPDMA 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0, Network:CORE 8.1.0, Network:Interface:ETH 8.1.0, Network:Socket:UDP 8.1.0
